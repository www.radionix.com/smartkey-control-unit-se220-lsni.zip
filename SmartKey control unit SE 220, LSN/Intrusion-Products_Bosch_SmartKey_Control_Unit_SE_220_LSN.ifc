Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Project Number
Time: 2023-06-21T17:05:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 17:05:28 2023 * Host: LIS-C-00085 * Database: C:\Users\MOA2OVR\AppData\Local\Temp\{173223DA-83C8-4E99-AB26-E62D6B24B26C}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 17:05:27 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 17:05:27 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 17:05:27 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: SmartKey control unit SE 220, LSN, Intrusion-Products_Bosch_SmartKey_Control_Unit_SE_220_LSN:SmartKey_Control_Unit_SE_220_LSN:218296
In: Level 1
Type - PredefinedType: FLOATING; Classification: Pr_75_80_42 Intrusion and hold-up alarm devices and control equipment (Uniclass 2015); Material: RAL 9002
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - 2DSymbolOffset: 5 mm; Dimension depth (mm): 35; Dimension height (mm): 160; Dimension width (mm): 135
Type - General - Environmental class: 2; IP Class: IP30; Mounting: Indoor Mounting; Operating temperature (°C) (maximum): 45; Operating temperature (°C) (minimum): -5; Operating voltage (VDC) (maximum): 30; Operating voltage (VDC) (minimum): 9.6
Type - Identity Data - CTN: IUI-SKCU2L-220; Description: SmartKey control unit SE 220, LSN; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SE_320_Installation_Manual_enUS_1433520779.pdf; Manufacturer: Bosch Security and Safety Systems; Material number: F.01U.523.519; Model: SmartKey blocking unit; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SE_320_Installation_Manual_enUS_1433520779.pdf; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SE_220_Data_sheet_enUS_1433429899.pdf; Product Website: https://commerce.boschsecurity.com/nlexp/en/SmartKey-arming-device-LSN-improved/p/F.01U.523.519/; Type Name: SmartKey_Control_Unit_SE_220_LSN
Type - Materials and Finishes - Color: RAL 9002; Color in RAL: Gray White; Material: ABS
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_SmartKey_Control_Unit_SE_220_LSN
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Volume: 0.000753416 m3
General - Panel Name: SmartKey control unit SE 220, LSN
Identity Data - Mark: 12
Other - Family: Intrusion-Products_Bosch_SmartKey_Control_Unit_SE_220_LSN: SmartKey_Control_Unit_SE_220_LSN; Family and Type: Intrusion-Products_Bosch_SmartKey_Control_Unit_SE_220_LSN: SmartKey_Control_Unit_SE_220_LSN; Schedule Level: Level: Level 1; Type: Intrusion-Products_Bosch_SmartKey_Control_Unit_SE_220_LSN: SmartKey_Control_Unit_SE_220_LSN; Type Id: Intrusion-Products_Bosch_SmartKey_Control_Unit_SE_220_LSN: SmartKey_Control_Unit_SE_220_LSN
Phasing - Phase Created: New Construction
